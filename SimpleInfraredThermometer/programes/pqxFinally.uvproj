# Keil uVision project pqxFinally.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: Test06 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\DRIVES;.\USER;.\RTXOS
  group DRIVES
    ./DRIVES/: PqxDelay.c PqxMLX90614.c PqxKeys.c PqxFont.c panquanxing.c OLED12832.c
    ./USER/: PqxMenus.c
  group USER
    ./USER/: taskStart.c taskKeys.c taskMLX90614.c taskEEPROM.c
  group RTXOS
    ./RTXOS/: Conf_tny.A51
